# Keil uVision project boot.uvprojx, settings and files
target Boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x8001FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F103xE
  c include: ../Core/Inc;../Core/Src;../../shared;../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../Core/Src/: main.c boot_uart.c boot_flash.c boot_crc.c boot_proto.c system_stm32f1xx.c
  group Startup
    ./: startup_stm32f103xe.s
