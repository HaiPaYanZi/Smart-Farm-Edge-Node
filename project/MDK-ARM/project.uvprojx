# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: project +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe --bin --output C:\Users\Administrator\Desktop\智慧农业控制节点项目\project\MDK-ARM\project\project.bin C:\Users\Administrator\Desktop\智慧农业控制节点项目\project\MDK-ARM\project\project.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./app;./Bsp;./Divece;./FreeModbus/modbus/include;./FreeModbus/modbus/port;./FreeModbus/modbus/rtu;./FreeModbus/modbus/functions;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../shared
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010200 size 0x18e00
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group App
    ./App/: log.c ota.c ota.h version.h log.h sd_log.c sd_log.h MySensor.c MySensor.h PID.c PID.h param.c param.h nvs.c nvs.h rule_engine.c rule_engine.h debug_cmd.c debug_cmd.h oled_page.c oled_page.h stall_detect.c stall_detect.h modbus_reg.c modbus_reg.h
  group Bsp
    ./Bsp/: board.h Delay.c Delay.h dsp_soft_IIC.c dsp_soft_IIC.h bsp_gpio.c bsp_gpio.h bsp_pwm.c bsp_pwm.h bsp_hal_counter.c bsp_hal_counter.h sd_spi.c sd_spi.h
  group Divece
    ./Divece/: MYOLED.c MYOLED.h OLED_Data.c OLED_Data.h AHT20.h AHT20.c BH1750.c BH1750.h soil_moisture.c soil_moisture.h fan.c fan.h light.c light.h pump.c pump.h buzzer.c buzzer.h
  group FreeModbus
    ./FreeModbus/modbus/: mb.c
    ./FreeModbus/modbus/rtu/: mbrtu.c mbcrc.c
    ./FreeModbus/modbus/functions/: mbfunccoils.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Port
    ./FreeModbus/modbus/port/: portevent.c portserial.c porttimer.c port.h
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.3.0
